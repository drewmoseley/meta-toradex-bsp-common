FILESEXTRAPATHS_prepend_toradex-bsp := "${THISDIR}/systemd-conf:"
