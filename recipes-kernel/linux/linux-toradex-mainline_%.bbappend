EXTRA_OEMAKE += "DTC_FLAGS=-@ "
DEPENDS_append = " lzop-native "
